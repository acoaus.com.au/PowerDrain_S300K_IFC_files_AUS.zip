Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 02669020-bf34-4a6b-be50-07a7b6357e2c, VersionGUID: 15ba4ed2-cf53-4639-a408-9fa2b3e6159f, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 142549.ifc
Time: 2026-05-28T12:11:47+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.30.11 (ENU) - IFC 24.3.30.11

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcDistributionPort (15)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_363115_1
OutPort_363115_2
OutPort_363115_3
OutPort_363115_4
OutPort_363115_5
OutPort_363115_6
OutPort_363115_7
OutPort_363115_8
OutPort_363115_9
OutPort_363115_10
OutPort_363115_11
OutPort_363115_12
OutPort_363115_13
OutPort_363115_14
OutPort_363115_15

# IfcFlowTerminal: PowerDrain_SK3-903 In-line pit (0.5m):SK3-903 In-line pit (0.5m), PowerDrain_SK3-903 In-line pit (0.5m):SK3-903 In-line pit (0.5m):363115
In: Level 1
Type - Description: ACO SK3-903 In-line pit (0.5m); PredefinedType: USERDEFINED; Material: PE, Black, Iron, Ductile, polymer concrete
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: SK3-903 In-line pit (0.5m); sets with these values: 2
PowerDrain S300K Schedule - code_supplier_article_C_ANZRS: 142549; Description: ACO SK3-903 In-line pit (0.5m); net_mass: 39.9 kg; Manufacturer: ACO; productrange: PowerDrain; content_creator: ACO Technology Centre, INDIA; URL: https://acodrain.com.au/products/; info_commercial: https://acodrain.com.au/trench-drains/powerdrain/; OmniClass Title: Rainwater Removal

# IfcFlowTerminal: ZZZ_do not use_PF_ST_PowerDrain_S300K_In-line pit_gratings_ACO:std(nested), ZZZ_do not use_PF_ST_PowerDrain_S300K_In-line pit_gratings_ACO:std(nested):363123
In: Level 1
Type - Description: ACO Grating for PowerDrain S300K; Material: Iron, Ductile
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
PowerDrain S300K Schedule - code_supplier_article_C_ANZRS: 142686; Description: ACO Grating for PowerDrain S300K; net_mass: 14.8 kg; Manufacturer: ACO; productrange: PowerDrain; content_creator: ACO Technology Centre, INDIA; URL: https://acodrain.com.au/; info_commercial: https://acodrain.com.au/trench-drains/powerdrain/; OmniClass Title: Rainwater Removal

# IfcFlowTerminal: ZZZ_do not use_PF_ST_PowerDrain_S300K_plastic_riser:std(nested) (5)
In: Level 1
Type - Description: Optional plastic riser; Material: PE, Black
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
PowerDrain S300K Schedule - code_supplier_article_C_ANZRS: 141729; Description: Optional plastic riser; net_mass: 4.5 kg; Manufacturer: ACO; productrange: PowerDrain; content_creator: ACO Technology Centre, INDIA; URL: www.acodrain.com.au; info_commercial: https://acodrain.com.au/trench-drains/powerdrain/; OmniClass Title: Rainwater Removal
Name (ZZZ_do not use_PF_ST_PowerDrain_S300K_plastic_riser:std(nested):...)
363323
363324
363325
363326
363327
